# Keil uVision project USB_PROG.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_PROG +hex
  c flags: Optim=1
  c include: .\SRC;.\SRC\chips;.\SRC\CMSIS\CoreSupport;.\SRC\CMSIS\DeviceSupport;.\SRC\Periph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./SRC/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./SRC/CMSIS/CoreSupport/: core_cm3.c
    ./SRC/CMSIS/DeviceSupport/: system_stm32f10x.c
  group STM32PPP_Drv
    ./SRC/Periph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ./SRC/: burn.c chip.c i2c_sim.c init.c main.c spi_sim.c stm32f10x_it.c uart.c utils.c
    ./SRC/chips/: cm2970.c m602.c m603.c
